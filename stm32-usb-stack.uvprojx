# Keil uVision project stm32-usb-stack.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-usb-stack
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ./inc/: main.h SysTick.h usb_core.h usb_ll.h usb_hid.h
    ./: trashcan.txt
  group src
    ./src/: main.c SysTick.c usb_core.c usb_ll.c usb_hid.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
